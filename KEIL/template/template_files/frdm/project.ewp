# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL43Z256xxx4 Freescale MKL43Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: LITTLE_ENDIAN
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include\; $TOOLKIT_DIR$\CMSIS\Lib\IAR\; ..\..\..\..\src\projects\_template_; ..\..\..\..\src\common\; ..\..\..\..\src\cpu\; ..\..\..\..\src\cpu\headers\; ..\..\..\..\src\cpu\IAR\; ..\..\..\..\src\liker files\IAR\; ..\..\..\..\src\drivers\; ..\..\..\..\src\drivers\adc; ..\..\..\..\src\drivers\bme; ..\..\..\..\src\drivers\cmp; ..\..\..\..\src\drivers\dac; ..\..\..\..\src\drivers\dma; ..\..\..\..\src\drivers\flexio; ..\..\..\..\src\drivers\flexio\flexio_uart; ..\..\..\..\src\drivers\flexio\flexio_i2c; ..\..\..\..\src\drivers\flexio\flexio_i2s; ..\..\..\..\src\drivers\flexio\flexio_spi_master; ..\..\..\..\src\drivers\flexio\flexio_spi_slave; ..\..\..\..\src\drivers\ftfa; ..\..\..\..\src\drivers\gpio; ..\..\..\..\src\drivers\i2c; ..\..\..\..\src\drivers\llwu; ..\..\..\..\src\drivers\lptmr; ..\..\..\..\src\drivers\lpuart; ..\..\..\..\src\drivers\mcg; ..\..\..\..\src\drivers\mcg_lite; ..\..\..\..\src\drivers\mcm; ..\..\..\..\src\drivers\osc; ..\..\..\..\src\drivers\pit; ..\..\..\..\src\drivers\pmc; ..\..\..\..\src\drivers\rcm; ..\..\..\..\src\drivers\rtc; ..\..\..\..\src\drivers\sai; ..\..\..\..\src\drivers\sim; ..\..\..\..\src\drivers\slcd; ..\..\..\..\src\drivers\smc; ..\..\..\..\src\drivers\spi; ..\..\..\..\src\drivers\tpm; ..\..\..\..\src\drivers\tsi; ..\..\..\..\src\drivers\uart; ..\..\..\..\src\drivers\usbd; ..\..\..\..\src\drivers\usbd\class; ..\..\..\..\src\drivers\usbd\hal; ..\..\..\..\src\drivers\usbd\usb_api\usb_hid; ..\..\..\..\src\drivers\vref; ..\..\..\..\src\utilities\fraclib; ..\..\..\..\src\utilities\fraclib\IAR; ..\..\..\..\src\utilities\freemaster; ..\..\..\..\src\utilities\tss; ..\..\..\..\src\devices\mma845x; ..\..\..\..\src\devices\fxos8700; ..\..\..\..\src\config files; ..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\src\linker files\IAR\256KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration 256KFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include\; $TOOLKIT_DIR$\CMSIS\Lib\IAR\; ..\..\..\..\src\projects\_template_; ..\..\..\..\src\common\; ..\..\..\..\src\cpu\; ..\..\..\..\src\cpu\headers\; ..\..\..\..\src\cpu\IAR\; ..\..\..\..\src\liker files\IAR\; ..\..\..\..\src\drivers\; ..\..\..\..\src\drivers\adc; ..\..\..\..\src\drivers\bme; ..\..\..\..\src\drivers\cmp; ..\..\..\..\src\drivers\dac; ..\..\..\..\src\drivers\dma; ..\..\..\..\src\drivers\flexio; ..\..\..\..\src\drivers\ftfa; ..\..\..\..\src\drivers\gpio; ..\..\..\..\src\drivers\i2c; ..\..\..\..\src\drivers\llwu; ..\..\..\..\src\drivers\lptmr; ..\..\..\..\src\drivers\lpuart; ..\..\..\..\src\drivers\mcg; ..\..\..\..\src\drivers\mcg_lite; ..\..\..\..\src\drivers\mcm; ..\..\..\..\src\drivers\osc; ..\..\..\..\src\drivers\pit; ..\..\..\..\src\drivers\pmc; ..\..\..\..\src\drivers\rcm; ..\..\..\..\src\drivers\rtc; ..\..\..\..\src\drivers\sai; ..\..\..\..\src\drivers\sim; ..\..\..\..\src\drivers\slcd; ..\..\..\..\src\drivers\smc; ..\..\..\..\src\drivers\spi; ..\..\..\..\src\drivers\tpm; ..\..\..\..\src\drivers\tsi; ..\..\..\..\src\drivers\uart; ..\..\..\..\src\drivers\vref; ..\..\..\..\src\utilities\filters; ..\..\..\..\src\utilities\freemaster; ..\..\..\..\src\utilities\tss; ..\..\..\..\src\devices\mma845x; ..\..\..\..\src\devices\fxos8700; ..\..\..\..\src\config files; ..\
configuration 32KRAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include\; $TOOLKIT_DIR$\CMSIS\Lib\IAR\; ..\..\..\..\src\projects\_template_; ..\..\..\..\src\common\; ..\..\..\..\src\cpu\; ..\..\..\..\src\cpu\headers\; ..\..\..\..\src\cpu\IAR\; ..\..\..\..\src\liker files\IAR\; ..\..\..\..\src\drivers\; ..\..\..\..\src\drivers\adc; ..\..\..\..\src\drivers\bme; ..\..\..\..\src\drivers\cmp; ..\..\..\..\src\drivers\dac; ..\..\..\..\src\drivers\dma; ..\..\..\..\src\drivers\flexio; ..\..\..\..\src\drivers\ftfa; ..\..\..\..\src\drivers\gpio; ..\..\..\..\src\drivers\i2c; ..\..\..\..\src\drivers\llwu; ..\..\..\..\src\drivers\lptmr; ..\..\..\..\src\drivers\lpuart; ..\..\..\..\src\drivers\mcg; ..\..\..\..\src\drivers\mcg_lite; ..\..\..\..\src\drivers\mcm; ..\..\..\..\src\drivers\osc; ..\..\..\..\src\drivers\pit; ..\..\..\..\src\drivers\pmc; ..\..\..\..\src\drivers\rcm; ..\..\..\..\src\drivers\rtc; ..\..\..\..\src\drivers\sai; ..\..\..\..\src\drivers\sim; ..\..\..\..\src\drivers\slcd; ..\..\..\..\src\drivers\smc; ..\..\..\..\src\drivers\spi; ..\..\..\..\src\drivers\tpm; ..\..\..\..\src\drivers\tsi; ..\..\..\..\src\drivers\uart; ..\..\..\..\src\drivers\vref; ..\..\..\..\src\other_drivers\filters; ..\..\..\..\src\other_drivers\freemaster; ..\..\..\..\src\other_drivers\tss; ..\..\..\..\src\other_drivers\mmax845x; ..\..\..\..\src\config files; ..\
  ILINK.IlinkIcfFile: ..\..\..\..\src\linker files\IAR\32KB_RAM.icf
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  ICCARM.CCIncludePath2: as above
  group CMSIS
    $EW_DIR$/arm/CMSIS/Include/: arm_math.h
    $EW_DIR$/arm/CMSIS/Lib/IAR/: iar_cortexM0l_math.a
  group common
    ../../../../src/common/: common.c common.h startup.c startup.h
  group cpu
    ../../../../src/cpu/: arch_delay.h arm_cm0.c arm_cm0.h device.h start.c start.h vectors.c vectors.h
    ../../../../src/cpu/IAR/: arch_delay.s crt0.s
  group cpu/headers
    ../../../../src/cpu/headers/: MKL43Z4.h MKL46Z4.h
  group devices/fxos8700
    ../../../../src/devices/fxos8700/: fxos8700.c fxos8700.h
  group devices/mma845x
    ../../../../src/devices/mma845x/: mma845x.c mma845x.h
  group drivers
    ../../../../src/drivers/: drivers.h
  group drivers/adc
    ../../../../src/drivers/adc/: adc.c adc.h
  group drivers/bme
    ../../../../src/drivers/bme/: bme.h
  group drivers/cmp
    ../../../../src/drivers/cmp/: cmp.c cmp.h
  group drivers/dac
    ../../../../src/drivers/dac/: dac.c dac.h
  group drivers/dma
    ../../../../src/drivers/dma/: dma.c dma.h
  group drivers/flexio
    ../../../../src/drivers/flexio/: flexio.c flexio.h flexio_test.txt
  group drivers/flexio/flexio_i2c
    ../../../../src/drivers/flexio/flexio_i2c/: flexio_i2c.c flexio_i2c.h
  group drivers/flexio/flexio_i2s
    ../../../../src/drivers/flexio/flexio_i2s/: flexio_i2s.c flexio_i2s.h
  group drivers/flexio/flexio_spi_master
    ../../../../src/drivers/flexio/flexio_spi_master/: flexio_spi_master.c flexio_spi_master.h
  group drivers/flexio/flexio_spi_slave
    ../../../../src/drivers/flexio/flexio_spi_slave/: flexio_spi_slave.c flexio_spi_slave.h
  group drivers/flexio/flexio_uart
    ../../../../src/drivers/flexio/flexio_uart/: flexio_uart.c flexio_uart.h
  group drivers/ftfa
    ../../../../src/drivers/ftfa/: ftfa.c ftfa.h
  group drivers/gpio
    ../../../../src/drivers/gpio/: gpio.c gpio.h
  group drivers/i2c
    ../../../../src/drivers/i2c/: i2c.c i2c.h
  group drivers/llwu
    ../../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../../src/drivers/lptmr/: lptmr.c
    ../../../../src/drivers/lptrm/: lptmr.h
  group drivers/lpuart
    ../../../../src/drivers/lpuart/: lpuart.c lpuart.h
  group drivers/mcg
    ../../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/mcg_lite
    ../../../../src/drivers/mcg_lite/: mcg_lite.c mcg_lite.h
  group drivers/mcm
    ../../../../src/drivers/mcm/: mcm.c mcm.h
  group drivers/osc
    ../../../../src/drivers/osc/: osc.c osc.h
  group drivers/pit
    ../../../../src/drivers/pit/: pit.c pit.h
  group drivers/pmc
    ../../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rtc
    ../../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/sai
    ../../../../src/drivers/sai/: sai.c sai.h
  group drivers/sim
    ../../../../src/drivers/sim/: sim.c sim.h
  group drivers/slcd
    ../../../../src/drivers/slcd/: lcd.c lcd.h lcdhdw.h
  group drivers/smc
    ../../../../src/drivers/smc/: smc.c smc.h
  group drivers/spi
    ../../../../src/drivers/spi/: spi.c spi.h
  group drivers/tpm
    ../../../../src/drivers/tpm/: tpm.c tpm.h
  group drivers/tsi
    ../../../../src/drivers/tsi/: tsi.c tsi.h
  group drivers/uart
    ../../../../src/drivers/uart/: uart.c uart.h
  group drivers/usbd
    ../../../../src/drivers/usbd/: usb_class.c usb_class.h usb_framework.c usb_framework.h
  group drivers/usbd/class
    ../../../../src/drivers/usbd/class/: usb_audio.c usb_audio.h usb_batt_chg.c usb_batt_chg.h usb_cdc.c usb_cdc.h usb_cdc_pstn.c usb_cdc_pstn.h usb_composite.c usb_composite.h usb_dfu.c usb_dfu.h usb_hid.c usb_hid.h usb_msc.c usb_msc.h usb_msc_scsi.c usb_msc_scsi.h usb_phdc.c usb_phdc.h usb_printer.c usb_printer.h usb_video.c usb_video.h
  group drivers/usbd/hal
    ../../../../src/drivers/usbd/hal/: usb_bdt_kinetis.h usb_dci_kinetis.c usb_dci_kinetis.h usb_dciapi.h usb_devapi.h usb_driver.c usbevent.c usbevent.h
  group drivers/usbd/usb_api/usb_hid
    ../../../../src/drivers/usbd/usb_api/usb_hid/: derivative.h types.h USB_Config.h usb_descriptor.c usb_descriptor.h usb_mouse.c usb_mouse.h user_config.h
  group drivers/usbd/usb_api/usb_vcom
    ../../../../src/drivers/usbd/usb_api/usb_vcom/: derivative.h types.h USB_Config.h usb_descriptor.c usb_descriptor.h usb_vcom.c usb_vcom.h usb_vcom_xp.inf user_config.h
  group drivers/vref
    ../../../../src/drivers/vref/: vref.c vref.h
  group linker files
    ../../../../src/linker files/IAR/: 256KB_Pflash.icf 32KB_RAM.icf
  group project
    ../../../../src/projects/_template_/: _template_.c appconfig.h freemaster_cfg.h
  group utilities/fraclib
    ../../../../src/utilities/fraclib/IAR/: fraclib.a
    ../../../../src/utilities/fraclib/: FRACLIB.h
  group utilities/freemaster
    ../../../../src/utilities/freemaster/: freemaster.h freemaster_appcmd.c freemaster_can.c freemaster_Kxx.c freemaster_Kxx.h freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_sfio.c freemaster_tsa.c freemaster_tsa.h
  group utilities/tss
    ../../../../src/utilities/tss/: derivative.h TSS_API.h TSS_DataTypes.h TSS_Freemaster.c TSS_GPIO.h TSS_KXX_M0.a TSS_Sensor.c TSS_Sensor.h TSS_SensorGPIO.c TSS_SensorGPIO.h TSS_SensorTSI.c TSS_SensorTSI.h TSS_SensorTSIL.c TSS_SensorTSIL.h TSS_StatusCodes.h TSS_SystemSetupData.c TSS_SystemSetupVal.h TSS_Timer.h
