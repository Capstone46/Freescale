# Keil uVision project project.uvprojx, settings and files
target project - Debug (ARM-ADS)
  device: MKL43Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x6000) IRAM2(0x1FFFE000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: project
  c flags: Optim=4 oTime=1
  c define: LITTLE_ENDIAN
  c misc: --diag_suppress=951 --c99 --bss_threshold=0
  c include: K\ARM\CMSIS\Lib;K\ARM\CMSIS\Include;..\..\..\..\src\projects\frdm_projects\frdm_accel_test;..\..\..\..\src\common;..\..\..\..\src\cpu;..\..\..\..\src\cpu\headers;..\..\..\..\src\cpu\KEIL;..\..\..\..\src\drivers;..\..\..\..\src\drivers\adc;..\..\..\..\src\drivers\bme;..\..\..\..\src\drivers\cmp;..\..\..\..\src\drivers\dac;..\..\..\..\src\drivers\dma;..\..\..\..\src\drivers\flexio;..\..\..\..\src\drivers\ftfa;..\..\..\..\src\drivers\gpio;..\..\..\..\src\drivers\i2c;..\..\..\..\src\drivers\lptmr;..\..\..\..\src\drivers\llwu;..\..\..\..\src\drivers\lptmr;..\..\..\..\src\drivers\lpuart;..\..\..\..\src\drivers\mcg;..\..\..\..\src\drivers\mcg_lite;..\..\..\..\src\drivers\mcm;..\..\..\..\src\drivers\osc;..\..\..\..\src\drivers\pit;..\..\..\..\src\drivers\pmc;..\..\..\..\src\drivers\rcm;..\..\..\..\src\drivers\rtc;..\..\..\..\src\drivers\sai;..\..\..\..\src\drivers\sim;..\..\..\..\src\drivers\slcd;..\..\..\..\src\drivers\smc;..\..\..\..\src\drivers\spi;..\..\..\..\src\drivers\tpm;..\..\..\..\src\drivers\tsi;..\..\..\..\src\drivers\uart;..\..\..\..\src\drivers\vref;..\..\..\..\src\utilities\freemaster;..\..\..\..\src\utilities\fraclib;..\..\..\..\src\utilities\fraclib\KEIL;..\..\..\..\src\devices\fxos8700;..\..\..\..\src\devices\mma845x;..\..\..\..\src\drivers\usbd;..\..\..\..\src\drivers\usbd\class;..\..\..\..\src\drivers\usbd\hal;..\..\..\..\src\drivers\usbd\usb_api\usb_hid;..\..\..\..\src\drivers\flexio\flexio_uart;..\..\..\..\src\drivers\flexio\flexio_i2c;..\..\..\..\src\drivers\flexio\flexio_i2s;..\..\..\..\src\drivers\flexio\flexio_spi_master;..\..\..\..\src\drivers\flexio\flexio_spi_slave;C:\Keil\ARM\CMSIS
  asm include: ..\..\..\..\src\cpu\KEIL
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ..\..\..\..\src\linker files\KEIL\256KB_Pflash.scf
  link misc: --entry=__startup --startup=main --diag_suppress=6314 --diag_suppress=6312 --diag_suppress=6329
  group common
    ../../../../src/common/: common.c common.h startup.c startup.h
  group cpu
    ../../../../src/cpu/: arch_delay.h arm_cm0.c arm_cm0.h device.h start.c start.h vectors.c vectors.h
    ../../../../src/cpu/headers/: MKL46Z4.h MKL43Z4.h
    ../../../../src/cpu/KEIL/: arch_delay.s crt0.s
    C:/Keil/ARM/CMSIS/: core_cm0.h
  group drivers
    ../../../../src/drivers/adc/: adc.c adc.h
    ../../../../src/drivers/bme/: bme.h
    ../../../../src/drivers/cmp/: cmp.c cmp.h
    ../../../../src/drivers/dac/: dac.h dac.c
    ../../../../src/drivers/dma/: dma.c dma.h
    ../../../../src/drivers/ftfa/: ftfa.h ftfa.c
    ../../../../src/drivers/gpio/: gpio.h gpio.c
    ../../../../src/drivers/i2c/: i2c.h i2c.c
    ../../../../src/drivers/llwu/: llwu.h llwu.c
    ../../../../src/drivers/mcg/: mcg.h mcg.c
    ../../../../src/drivers/osc/: osc.h osc.c
    ../../../../src/drivers/pit/: pit.h pit.c
    ../../../../src/drivers/pmc/: pmc.h pmc.c
    ../../../../src/drivers/rtc/: rtc.c rtc.h
    ../../../../src/drivers/sim/: sim.c sim.h
    ../../../../src/drivers/slcd/: lcdhdw.h lcd.h lcd.c
    ../../../../src/drivers/smc/: smc.h smc.c
    ../../../../src/drivers/spi/: spi.h spi.c
    ../../../../src/drivers/tpm/: tpm.h tpm.c
    ../../../../src/drivers/tsi/: tsi.h tsi.c
    ../../../../src/drivers/uart/: uart.h uart.c
    ../../../../src/drivers/: drivers.h
    ../../../../src/drivers/lptmr/: lptmr.c lptmr.h
    ../../../../src/drivers/flexio/: flexio.c flexio.h
    ../../../../src/drivers/lpuart/: lpuart.c lpuart.h
    ../../../../src/drivers/mcg_lite/: mcg_lite.c mcg_lite.h
    ../../../../src/drivers/mcm/: mcm.h mcm.c
    ../../../../src/drivers/rcm/: rcm.h rcm.c
    ../../../../src/drivers/sai/: sai.h sai.c
    ../../../../src/drivers/vref/: vref.h vref.c
    ../../../../src/drivers/usbd/: usb_class.c usb_class.h usb_framework.c usb_framework.h
    ../../../../src/drivers/usbd/class/: usb_audio.c usb_batt_chg.c usb_cdc.c usb_cdc_pstn.c usb_composite.c usb_dfu.c usb_hid.c usb_hid.h usb_msc.c usb_msc_scsi.c usb_phdc.c usb_printer.c usb_video.c
    ../../../../src/drivers/usbd/hal/: usb_bdt_kinetis.h usb_dci_kinetis.c usb_dci_kinetis.h usb_dciapi.h usb_devapi.h usb_driver.c usbevent.c usbevent.h
    ../../../../src/drivers/usbd/usb_api/usb_hid/: derivative.h types.h USB_Config.h usb_descriptor.c usb_descriptor.h usb_mouse.c usb_mouse.h user_config.h
    ../../../../src/drivers/flexio/flexio_i2c/: flexio_i2c.c flexio_i2c.h
    ../../../../src/drivers/flexio/flexio_i2s/: flexio_i2s.c flexio_i2s.h
    ../../../../src/drivers/flexio/flexio_spi_master/: flexio_spi_master.c flexio_spi_master.h
    ../../../../src/drivers/flexio/flexio_spi_slave/: flexio_spi_slave.c flexio_spi_slave.h
  group project
    ../../../../src/projects/frdm_projects/frdm_accel_test/: appconfig.h freemaster_cfg.h frdm_accel_test.c
  group linker files
    ../../../../src/linker files/KEIL/: 256KB_Pflash.scf 32KB_RAM.scf
  group devices
    ../../../../src/devices/fxos8700/: fxos8700.c fxos8700.h
    ../../../../src/devices/mma845x/: mma845x.h mma845x.c
  group utilities
    ../../../../src/utilities/freemaster/: freemaster.h freemaster_appcmd.c freemaster_can.c freemaster_Kxx.c freemaster_Kxx.h freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_sfio.c freemaster_tsa.c freemaster_tsa.h
    ../../../../src/utilities/fraclib/: FRACLIB.h
    ../../../../src/utilities/fraclib/KEIL/: fraclib.lib
target project - 256KFLASH (ARM-ADS)
  device: MKL43Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1
  c misc: --diag_suppress=951 --c99  --bss_threshold=0
  c include: K\ARM\CMSIS\Lib;K\ARM\CMSIS\Include;..\..\..\..\src\projects\frdm_projects\frdm_accel_test;..\..\..\..\src\common;..\..\..\..\src\cpu;..\..\..\..\src\cpu\headers;..\..\..\..\src\cpu\KEIL;..\..\..\..\src\drivers;..\..\..\..\src\drivers\adc;..\..\..\..\src\drivers\bme;..\..\..\..\src\drivers\cmp;..\..\..\..\src\drivers\dac;..\..\..\..\src\drivers\dma;..\..\..\..\src\drivers\flexio;..\..\..\..\src\drivers\ftfa;..\..\..\..\src\drivers\gpio;..\..\..\..\src\drivers\i2c;..\..\..\..\src\drivers\lptmr;..\..\..\..\src\drivers\llwu;..\..\..\..\src\drivers\lptmr;..\..\..\..\src\drivers\lpuart;..\..\..\..\src\drivers\mcg;..\..\..\..\src\drivers\mcg_lite;..\..\..\..\src\drivers\mcm;..\..\..\..\src\drivers\osc;..\..\..\..\src\drivers\pit;..\..\..\..\src\drivers\pmc;..\..\..\..\src\drivers\rcm;..\..\..\..\src\drivers\rtc;..\..\..\..\src\drivers\sai;..\..\..\..\src\drivers\sim;..\..\..\..\src\drivers\slcd;..\..\..\..\src\drivers\smc;..\..\..\..\src\drivers\spi;..\..\..\..\src\drivers\tpm;..\..\..\..\src\drivers\tsi;..\..\..\..\src\drivers\uart;..\..\..\..\src\drivers\vref;..\..\..\..\src\utilities\freemaster;..\..\..\..\src\utilities\filters;..\..\..\..\src\devices\fxos8700;..\..\..\..\src\devices\mma845x;..\..\..\..\src\utilities\tss;C:\Keil\ARM\CMSIS
  asm include: ..\..\..\..\src\cpu\KEIL
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: ..\..\..\..\src\linker files\KEIL\256KB_Pflash.scf
  link misc: as above
target project - 32KRAM (ARM-ADS)
  device: MKL46Z256xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: project
  c flags: Optim=4 oTime=1
  c misc: --diag_suppress=951 --c99 --bss_threshold=0
  c include: K\ARM\CMSIS\Lib;K\ARM\CMSIS\Include;..\..\..\..\src\projects\frdm_projects\frdm_accel_test;..\..\..\..\src\common;..\..\..\..\src\cpu;..\..\..\..\src\cpu\headers;..\..\..\..\src\cpu\KEIL;..\..\..\..\src\drivers;..\..\..\..\src\drivers\adc;..\..\..\..\src\drivers\bme;..\..\..\..\src\drivers\cmp;..\..\..\..\src\drivers\dac;..\..\..\..\src\drivers\dma;..\..\..\..\src\drivers\flexio;..\..\..\..\src\drivers\ftfa;..\..\..\..\src\drivers\gpio;..\..\..\..\src\drivers\i2c;..\..\..\..\src\drivers\lptmr;..\..\..\..\src\drivers\llwu;..\..\..\..\src\drivers\lptmr;..\..\..\..\src\drivers\lpuart;..\..\..\..\src\drivers\mcg;..\..\..\..\src\drivers\mcg_lite;..\..\..\..\src\drivers\mcm;..\..\..\..\src\drivers\osc;..\..\..\..\src\drivers\pit;..\..\..\..\src\drivers\pmc;..\..\..\..\src\drivers\rcm;..\..\..\..\src\drivers\rtc;..\..\..\..\src\drivers\sai;..\..\..\..\src\drivers\sim;..\..\..\..\src\drivers\slcd;..\..\..\..\src\drivers\smc;..\..\..\..\src\drivers\spi;..\..\..\..\src\drivers\tpm;..\..\..\..\src\drivers\tsi;..\..\..\..\src\drivers\uart;..\..\..\..\src\drivers\vref;..\..\..\..\src\other_drivers\freemaster;..\..\..\..\src\other_drivers\filters;..\..\..\..\src\other_drivers\fxos8700;..\..\..\..\src\other_drivers\mmax845x;..\..\..\..\src\other_drivers\tss
  asm include: ..\..\..\..\src\cpu\KEIL
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: ..\..\..\..\src\linker files\KEIL\32KB_RAM.scf
  link misc: as above
